## boards/shields/whn_1/Kconfig.defconfig
```kconfig
if SHIELD_WHN_1

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "WHN 1"

endif
```
